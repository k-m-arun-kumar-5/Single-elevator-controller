# Keil uVision project elevator_04.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: elevator_04 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s appl.c dev_oper.c elev_fsm_part_1.c elev_fsm_part_2.c elev_fsm_part_3.c elev_fsm_part_4.c elev_fsm_part_5.c io_lib.c isr.c main.c seg7_lib.c std_lib.c timer.c uart.c appl.h appl_conf.h constants.h dev_chs_map.h dev_oper.h elevator_fsm.h io_conf.h io_lib.h isr.h main.h misc_ids_map.h port.h seg7_lib.h std_lib.h sys_status.h timer.h uart.h sw_lib.h sw_lib.c
